# Keil uVision project OBD-II-V1.0.uvproj, settings and files
target OBD-II-V1.0 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OBD-II-V1.0 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE;..\EXTI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c port.c Test.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/: timer2.c iwdg.c spi.c flash.c usart.c debug.c GSM.c OBD.c alarm.c upload.c asm.c
  group EXTI
    ../EXTI/: exti.c
